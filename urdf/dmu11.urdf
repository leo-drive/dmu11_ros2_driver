Commit message: add sensor description and rviz

File: urdf/dmu11.urdf (robot description, URDF)
Before this commit: robot dmu11, 1 links, 0 joints
Links:
- removed link base_link
- added link imu_link; visual mesh filename=package://dmu11_ros2_driver/meshes/dmu11.stl scale=0.1 0.1 0.1
